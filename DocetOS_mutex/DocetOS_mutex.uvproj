# Keil uVision project DocetOS_mutex.uvproj, settings and files
target STM32F407 Flash (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: DocetOS_mutex
  c flags: Optim=1 wLevel=2
  c misc: --c99
  c include: .\OS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group System
    ./utils/: retarget.c system_stm32f4xx.c startup_stm32f4xx.s serial.c
  group Source Files
    ./: main.c simpleRoundRobin.c
    ./Mutex/: mutex.c
  group OS
    ./OS/: os_asm.s os.c
  group Debug
    ./utils/: hardfault.c
target STM32F407 RAM (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: DocetOS_mutex
  c flags: Optim=1
  c define: VECT_TAB_SRAM
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
